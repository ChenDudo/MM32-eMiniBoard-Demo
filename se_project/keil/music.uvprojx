# Keil uVision project music.uvprojx, settings and files
target MB020 (ARM-ADS)
  device: MM32W051PFB MindMotion
  pack: MindMotion.MM32W0xxB_DFP.1.0.5
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: music
  c flags: Optim=1 uC99=1
  c define: __KEIL __MZ309 __MM32_MB020  CLOCK=8000000
  c include: ..\..\se_app\uid\inc;..\..\lib\HAL_lib\inc;..\..\lib\startup\inc;..\..\bsp\inc;..\..\ble\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\_config\mm32f031x6.sct
  group app
    ../../se_app/uid/: adc.c hci.c main.c music.c
  group ble
    ../../ble/: ble.c wl_ble_lowpower.c wl_ble_services.c wl_hw.c
    ../../ble/lib/: mg_BLEPAIR_lib.lib
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_beep.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_i2c.c bsp_key.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_spi.c bsp_tim.c bsp_uart.c
  group lib
    ../../lib/HAL_lib/: common.c HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    ../../lib/startup/: startup_mm32.c system_mm32.c
target MB021 (ARM-ADS)
  device: MM32W373PFB MindMotion
  pack: MindMotion.MM32W3xxB_DFP.1.0.8
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: music
  c flags: Optim=1 uC99=1
  c define: __KEIL __MT304 __MM32_MB021 CLOCK=8000000
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\_config\MM32L373.sct
target MB022 (ARM-ADS)
  device: MM32F031C6T MindMotion
  pack: MindMotion.MM32F031_DFP.1.4.1
  cpu: as above
  output: music
  c flags: Optim=1 uC99=1
  c define: __KEIL __MZ309  __MM32_MB022  CLOCK=8000000
  c include: ..\..\se_app\uid\inc;..\..\lib\HAL_lib\inc;..\..\lib\startup\inc;..\..\bsp\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\_config\mm32f031x6.sct
target MB023 (ARM-ADS)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.1.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: music
  c flags: Optim=1 uC99=1
  c define: __KEIL __MZ306  __MM32_MB023  CLOCK=8000000
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\_config\MM32L073.sct
target MB024 (ARM-ADS)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.7
  cpu: as above
  output: music
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __KEIL __MT304 __MM32_MB024  CLOCK=8000000
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\_config\MM32L373.sct
target MB025 (ARM-ADS)
  device: MM32F032R8T6 MindMotion
  pack: MindMotion.MM32F032_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: music
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __KEIL __MZ310  __MM32_MB025  CLOCK=8000000
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\_config\MM32L073.sct
target MB032 (ARM-ADS)
  device: MM32F0010A1T MindMotion
  pack: MindMotion.MM32F0010_DFP.1.0.4
  cpu: IROM(0x08000000,0x00004000) IRAM(0x20000000,0x00000800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: music +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __KEIL __MZ311  __MM32_MB032  CLOCK=8000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: .\_config\mm32f031x6.sct
software components: CMSIS:CORE 4.1.0
