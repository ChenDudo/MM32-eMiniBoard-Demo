# IAR project music.ewp, settings and files
configuration MB024 (ARM, debug)
  General.OGChipSelectEditMenu: MM32L373PF MindMotion MM32L373PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MT304; __MM32_MB024; CLOCK=8000000
  ICCARM.CCIncludePath2: ..\..\bsp\inc; ..\..\driver\inc; ..\..\se_app\uid\inc; ..\..\lib\HAL_lib\inc; ..\..\lib\startup\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MT304
  OBJCOPY.OOCOutputFile: se_uid.srec
  ILINK.IlinkOutputFile: uid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB023 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32L073PF MindMotion MM32L073PF
  General.CoreVariant: 34
  ICCARM.CCDefines: __IAR; __MZ306; __MM32_MB023; CLOCK=8000000
  AARM.ADefines: MZ306
  OBJCOPY.OOCOutputFile: uid.hex
configuration MB025 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32F0133C7P MindMotion MM32F0133C7P
  General.CoreVariant: 34
  ICCARM.CCDefines: __IAR; __MZ310; __MM32_MB025; CLOCK=8000000
  AARM.ADefines: MZ306
  OBJCOPY.OOCOutputFile: uid.hex
configuration MB022 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32F031C6T MindMotion MM32F031C6T
  General.CoreVariant: 34
  ICCARM.CCDefines: __IAR; __MZ309; __MM32_MB022; CLOCK=8000000
  AARM.ADefines: MZ306
  OBJCOPY.OOCOutputFile: uid.hex
configuration MB032 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32F0010A1T MindMotion MM32F0010A1T
  General.CoreVariant: 34
  ICCARM.CCDefines: __IAR; __MZ311; __MM32_MB032; CLOCK=8000000
  AARM.ADefines: MZ306
configuration MB021 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __IAR; __MT304; __MM32_MB021; CLOCK=8000000
  ICCARM.CCIncludePath2: ..\..\bsp\inc; ..\..\se_app\uid\inc; ..\..\lib\HAL_lib\inc; ..\..\lib\startup\inc; ..\..\ble\inc
  ILINK.IlinkAdditionalLibs: ..\..\ble\lib\mg_BLEPAIR_lib_m0.lib
configuration MB020 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32F031C6T MindMotion MM32F031C6T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  ICCARM.CCDefines: __IAR; __MZ309; __MM32_MB020; CLOCK=8000000
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: MZ306
  OBJCOPY.OOCOutputFile: music.srec
  ILINK.IlinkAdditionalLibs: ..\..\ble\lib\mg_BLE_libv4_m0.lib
  group app
    ../../se_app/uid/: adc.c hci.c main.c music.c
  group ble
    ../../ble/: ble.c
  group ble/lib
    ../../ble/: wl_ble_lowpower.c wl_ble_services.c wl_hw.c
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_beep.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_i2c.c bsp_key.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_spi.c bsp_tim.c bsp_uart.c
  group lib
    ../../lib/HAL_lib/: common.c HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    ../../lib/startup/: startup_mm32.c system_mm32.c
